File: tinybee_v1.brd (EAGLE design)
At the start: 47.6 x 27.8 mm, 22 parts, among them U1 ATTINY85-20S

Commit message: More cleanup
Routing:
- net VBUS: track 16.4 -> 16.9 mm, vias 1 -> 3
